# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6230000::V6.23::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: bootloader +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c misc: -Oz
  c include: ../Core/Inc;  ../Drivers/STM32G4xx_HAL_Driver/Inc;  ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;  ../Drivers/CMSIS/Include;  ..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group app
    ../app/: error_trace.c modbus_port.c modbus.c sha256.c upgrade.c upgrade_flash.c upgrade_platform.c
software components: CMSIS:CORE 6.1.0
